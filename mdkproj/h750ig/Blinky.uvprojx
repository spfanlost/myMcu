# Keil uVision project Blinky.uvprojx, settings and files
target h750vb_ram (6140000::V6.14::ARMCLANG)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: h750vb_ram +hex
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\src\startup\CMSIS\Include;..\..\src\startup\Device\STM32H7xx\Include;..\..\src\startup;..\..\src\msic;..\..\src\gpio;..\..\src\led;..\..\src\uart;..\..\src\adc;..\..\src\lcd;..\..\src
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group app
    ../../src/app/: myh750_main.c
  group msic
    ../../src/msic/: retarget.c cmdline.c task.c
  group mcu
    ../../src/mcu/: mcu.h mcu_isr.c
  group library
    ../../src/library/STM32H7xx_HAL_Driver/Src/: stm32h7xx_ll_usart.c stm32h7xx_ll_utils.c stm32h7xx_ll_rcc.c stm32h7xx_ll_gpio.c
  group cmsis
    ../../src/cmsis/Device/STM32H7xx/Source/Templates/: system_stm32h7xx.c
    ../../src/cmsis/Device/STM32H7xx/Source/Templates/arm/: startup_stm32h750xx.s
target h750vb_flash (6150000::V6.15::ARMCLANG)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: as above
  output: h750vb_flash +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32H750xx,USE_FULL_LL_DRIVER,HSE_VALUE=8000000
  c include: ..\..\src\cmsis\Include;..\..\src\cmsis\Device\STM32H7xx\Include;..\..\src\library\STM32H7xx_HAL_Driver\Inc;..\..\src\app;..\..\src\mcu;..\..\src\msic;..\..\src\driver;..\..\src\bsp\myh750
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
