# Keil uVision project Blinky.uvprojx, settings and files
target f407zg_ram (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: f407zg_ram +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F407xx
  c include: ..\..\src\cmsis\Include;..\..\src\cmsis\Device\STM32F4xx\Include;..\..\src\mcu;..\..\src\msic;..\..\src\driver;..\..\src\driver\lcd;..\..\src\res\fonts;..\..\src\res\logos;..\..\src\driver\bsp\myf407
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../../src/app/: myf407_main.c
  group msic
    ../../src/msic/: retarget.c cmdline.c
  group driver
    ../../src/driver/: drv_led.c
    ../../src/driver/lcd/: drv_lcd.c drv_ili9325.c
    ../../src/driver/bsp/myf407/: bsp_myf407_led.c
  group mcu
    ../../src/mcu/: mcu.h mcu_sys.c mcu_isr.c mcu_io.c mcu_uart.c mcu_adc.c
  group cmsis
    ../../src/cmsis/Device/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../src/cmsis/Device/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group fonts
    ../../src/res/fonts/: font_6x12.c font_8x16.c font_12x24.c
  group logos
    ../../src/res/logos/: mylogo.c
target f407zg_flash (6140000::V6.14::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: as above
  output: f407zg_flash +hex
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\src\startup\CMSIS\Include;..\..\src\startup\Device\STM32F4xx\Include;..\..\src\msic;..\..\src\gpio;..\..\src\led;..\..\src\usart;..\..\src\adc;..\..\src\lcd;..\..\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
