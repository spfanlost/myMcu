# Keil uVision project Blinky.uvprojx, settings and files
target f429ig_flash (6160000::V6.16::ARMCLANG)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: f429ig_flash +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F429xx,USE_FULL_LL_DRIVER,HSE_VALUE=25000000
  c include: ..\..\src\cmsis\Include;..\..\src\cmsis\Device\STM32F4xx\Include;..\..\src\library\STM32F4xx_HAL_Driver\Inc;..\..\src\app;..\..\src\bsp\myf429;..\..\src\mcu;..\..\src\msic
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../../src/app/: myf429_main.c
  group bsp
    ../../src/bsp/myf429/: ltdc.c sdram.c
  group msic
    ../../src/msic/: retarget.c cmdline.c task.c
  group mcu
    ../../src/mcu/: mcu.h mcu_isr.c
  group library
    ../../src/library/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_usart.c stm32f4xx_ll_utils.c stm32f4xx_ll_rcc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c
  group cmsis
    ../../src/cmsis/Device/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../src/cmsis/Device/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
