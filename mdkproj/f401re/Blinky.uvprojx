# Keil uVision project Blinky.uvprojx, settings and files
target f401re_ram (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: f401re_ram +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F401xE
  c include: ..\..\src\cmsis\Include;..\..\src\cmsis\Device\STM32F4xx\Include;..\..\src\mcu;..\..\src\msic;..\..\src\driver;..\..\src\driver\bsp\myf401
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group app
    ../../src/app/: myf401_main.c
  group msic
    ../../src/msic/: retarget.c cmdline.c
  group driver
    ../../src/driver/: drv_led.c
    ../../src/driver/bsp/myf401/: bsp_myf401_led.c
  group mcu
    ../../src/mcu/: mcu.h mcu_sys.c mcu_isr.c mcu_io.c mcu_uart.c mcu_adc.c
  group cmsis
    ../../src/cmsis/Device/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../../src/cmsis/Device/STM32F4xx/Source/Templates/arm/: startup_stm32f401xe.s
target f401re_flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Blinky
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __USE_LCD __STM_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
